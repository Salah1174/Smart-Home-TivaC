# IAR project SmartHome.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Salma\.vscode\Smart-Home-TivaC\Drivers\TivaLib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmartHome.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group HAL/AlarmMod
    ../Drivers/HAL/AlarmMod/: Alarm.c Alarm.h
  group HAL/RelayMod
    ../Drivers/HAL/RelayMod/: Relay.c Relay.h
  group MCAL
    ../Drivers/TivaLib/driverlib/ewarm/Exe/: driverlib.a
  group MCAL/DIO
    ../Drivers/MCAL/DIO/: bitwise_operations.h DIO.c DIO.h tm4c123gh6pm.h
  group MCAL/GPIO
    ../Drivers/MCAL/GPIO/: GPIO.c GPIO.h
    ../../../Documents/YA5TAAAAY/embedded/labs/lab 6 (Adavnced GPIO lab 4)/: types.h
  group MCAL/UART
    ../Drivers/MCAL/UART/: std_types.h tm4c123gh6pm_registers.h uart0.c uart0.h uart5.c uart5.h
